EXTRA_OECONF += " \
	--enable-ftp \
	--enable-sysvshm \
	--enable-sysvmsg \
	--enable-sysvsem \
	--enable-debug \
	"
